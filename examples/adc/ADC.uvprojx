# Keil uVision project ADC.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fo
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F10X_HD
  c include: ..\..\lib\wyCppHal;..\..\lib\CMSIS;..\..\lib
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ../../lib/startup/: startup_stm32f10x_hd.s
    ../../lib/CMSIS/: system_stm32f10x.c
  group HAL
    ../../lib/wyCppHal/: wyGpio.cpp wySys.cpp wyUsart.cpp wyADC.cpp wyDMA.cpp chipf10x.cpp
  group User
    ./: main.cpp
